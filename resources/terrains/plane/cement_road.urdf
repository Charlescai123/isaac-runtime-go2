Commit message: Modularize WildEnv & Cleanup

File: resources/terrains/plane/cement_road.urdf (robot description, URDF)
Before this commit: robot floor, 1 links, 0 joints
Links:
- link floor: geometry collision box size=6 2 0.001; visual mesh filename=cement_road.obj scale=0.03 0.01 0.1
